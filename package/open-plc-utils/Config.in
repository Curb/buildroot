## package/open-plc-utils/Config.in
```kconfig
config BR2_PACKAGE_OPEN_PLC_UTILS
	bool "open-plc-utils"
	help
	  This package is an open version of the Qualcomm Atheros Powerline 
	  Toolkit. 
```
